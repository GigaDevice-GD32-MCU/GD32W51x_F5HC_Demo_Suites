# Keil uVision project usbh_msc.uvprojx, settings and files
target usbh_msc (6220000::V6.22::ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_B513_F5HC_DFP.0.0.2
  cpu: IRAM(0x20000000,0x70000) IRAM2(0x30000000,0x70000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: usbh_msc +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,SYS_NS,GD32W515
  c include: ..\inc;..\fat_fs\inc;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\CMSIS\GD\GD32W51x_F5HC\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_standard_peripheral\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\driver\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\host\core\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\ustd\class\msc;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\host\class\msc\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\ustd\common;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
  group Application
    ../src/: gd32w51x_f5hc_it.c gd32w51x_f5hc_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32w51x_f5hc.c
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/: gd32w51x_f5hc_err_report.c
  group GD32W51x_Peripherals
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_exti.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_pmu.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_usart.c
  group GD32W515_EVAL
    ../../../../Utilities/: gd32w515p_eval.c
  group Startup
    ../src/: startup_gd32w515.s
  group USB_Driver
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FATFS
    ../fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.0
