# IAR project usbh_msc.ewp, settings and files
configuration GD32F5HC (ARM, debug)
  General.OGChipSelectEditMenu: GD32F5HCxI GD GD32F5HCxI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; USE_FATFS; SYS_NS; GD32F5HC
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\CMSIS\GD\GD32W51x_F5HC\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_standard_peripheral\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\driver\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\host\core\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\host\class\msc\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\ustd\common; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\ustd\class\msc; ..\fat_fs\inc; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbh_hid.srec
  ILINK.IlinkOutputFile: usbh_msc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32w51x_f5hc_it.c gd32w51x_f5hc_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/: gd32w51x_f5hc_err_report.c
    ../src/: system_gd32w51x_f5hc.c
  group Doc
    ../: readme.txt
  group FATFS
    ../fat_fs/src/: ff.c ffunicode.c
  group GD32F5HC_Peripherals
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_exti.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_pmu.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_usart.c
  group GD32F5HC_START
    ../../../../Utilities/: gd32f5hcp_start.c
  group Startup
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/IAR/: startup_gd32f5hc.s
  group USB_Class
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
