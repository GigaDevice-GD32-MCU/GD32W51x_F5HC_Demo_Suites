# Keil uVision project usbh_hid.uvprojx, settings and files
target usbh_hid (6220000::V6.22::ARMCLANG)
  device: GD32F5HCRI GigaDevice
  pack: GigaDevice.GD32W51x_B513_F5HC_DFP.0.0.2
  cpu: IRAM(0x20000000,0x50000) IRAM2(0x30000000,0x50000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: usbh_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,SYS_NS,GD32F5HC
  c include: ..\inc;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\CMSIS\GD\GD32W51x_F5HC\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_standard_peripheral\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\driver\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\host\core\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\host\class\hid\Include;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\ustd\class\hid;..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\ustd\common;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x30000000 size 0x50000
  group Application
    ../src/: main.c usbh_usr.c gd32w51x_f5hc_it.c gd32w51x_f5hc_usb_hw.c
  group CMSIS
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/: gd32w51x_f5hc_err_report.c
    ../src/: system_gd32w51x_f5hc.c
  group GD32F5HC_Peripherals
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_exti.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_pmu.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_usart.c
  group GD32F5HC_START
    ../../../../Utilities/: gd32f5hcp_start.c
  group Startup
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/ARM/: startup_gd32f5hc.s
  group USB_Driver
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.0
