# IAR project cdc_acm.ewp, settings and files
configuration GD32F5HC (ARM, debug)
  General.OGChipSelectEditMenu: GD32F5HCxI GD GD32F5HCxI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; SYS_NS; GD32F5HC; FW_DEBUG_ERR_REPORT
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\CMSIS\GD\GD32W51x_F5HC\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_standard_peripheral\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\driver\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\device\core\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\device\class\cdc\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\ustd\class\cdc; ..\..\..\..\Utilities; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: cdc_acm.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c gd32w51x_f5hc_hw.c gd32w51x_f5hc_it.c
  group CMSIS
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/: gd32w51x_f5hc_err_report.c
    ../src/: system_gd32w51x_f5hc.c
  group Doc
    ../: readme.txt
  group GD32F5HC_Peripherals
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_exti.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_usart.c
  group GD32F5HC_START
    ../../../../Utilities/: gd32f5hcp_start.c
  group Startup
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/IAR/: startup_gd32f5hc.s
  group USB_Class
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group USB_Device
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
