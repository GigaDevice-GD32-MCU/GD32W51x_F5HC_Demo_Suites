<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GD32F5HCP_START_NON_SECURE.ewp</path>
    </project>
</workspace>
