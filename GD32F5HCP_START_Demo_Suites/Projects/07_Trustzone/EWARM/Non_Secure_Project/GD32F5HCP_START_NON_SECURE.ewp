# IAR project GD32F5HCP_START_NON_SECURE.ewp, settings and files
configuration GD32F5HC (ARM, debug)
  General.OGChipSelectEditMenu: GD32F5HCxI_TZ GD GD32F5HCxI_TZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; SYS_NS; GD32F5HC; FW_DEBUG_ERR_REPORT
  ICCARM.CCIncludePath2: ..\..\NSecure_Code; ..\..\..\..\Utilities; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\CMSIS\GD\GD32W51x_F5HC\Include; ..\..\..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_standard_peripheral\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32F5HCR_EVAL_NON_SECURE.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\NSecure_Code\gd32f5hc_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ..\Secure_Project\GD32F5HC\Exe\secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../NSecure_Code/: gd32w51x_f5hc_it.c main.c systick.c
  group CMSIS
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/: gd32w51x_f5hc_err_report.c system_gd32w51x_f5hc.c
  group Doc
    ../../: readme.txt
  group GD32F5HCP_START
    ../../../../Utilities/: gd32f5hcp_start.c
  group GD32F5HC_Peripherals
    ../../../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_adc.c gd32w51x_f5hc_cau.c gd32w51x_f5hc_cau_aes.c gd32w51x_f5hc_cau_des.c gd32w51x_f5hc_cau_tdes.c gd32w51x_f5hc_crc.c gd32w51x_f5hc_ctc.c gd32w51x_f5hc_dbg.c gd32w51x_f5hc_dci.c gd32w51x_f5hc_dma.c gd32w51x_f5hc_efuse.c gd32w51x_f5hc_exti.c gd32w51x_f5hc_fmc.c gd32w51x_f5hc_fwdgt.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_hau.c gd32w51x_f5hc_hau_sha_md5.c gd32w51x_f5hc_hpdf.c gd32w51x_f5hc_i2c.c gd32w51x_f5hc_icache.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_pkcau.c gd32w51x_f5hc_pmu.c gd32w51x_f5hc_qspi.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_rtc.c gd32w51x_f5hc_sdio.c gd32w51x_f5hc_spi.c gd32w51x_f5hc_sqpi.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_trng.c gd32w51x_f5hc_tsi.c gd32w51x_f5hc_tzpcu.c gd32w51x_f5hc_usart.c gd32w51x_f5hc_wwdgt.c
  group Startup
    ../../../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/IAR/: startup_gd32f5hc.s
